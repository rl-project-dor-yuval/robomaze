Commit message: Added collision detection mechanism for the relevant collisions

File: data/goalSphere.urdf (robot description, URDF)
Before this commit: robot Sphere, 1 links, 0 joints
Links:
- link base_link: geometry collision sphere radius=1; visual sphere radius=1
