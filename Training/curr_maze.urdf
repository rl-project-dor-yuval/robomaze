Commit message: Tried to keep training the trained model

File: Training/curr_maze.urdf (robot description, URDF)
Before this commit: robot maze.urdf, 1 links, 0 joints
Links:
- link baselink: geometry collision box size=0.1 0.1 1; collision box size=0.1 0.1 1
